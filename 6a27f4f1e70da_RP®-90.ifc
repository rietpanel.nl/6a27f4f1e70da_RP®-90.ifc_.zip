Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: f4cbec20-dcb8-4ba4-bb69-27833569e8ba, VersionGUID: e955c08b-c2c1-4b4a-89ec-4fabb9aff6d2, NumberOfSaves: 0], CoordinateReference [CoordinateBase: Shared Coordinates]
File name: RP90.ifc
Time: 2026-06-08T21:18:51+01:00
Written by: ODA SDAI 25.12
Made in: Autodesk - Revit 27.0.20.10 (ENU) - 27.0.20.10

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 2

# IfcBuildingStorey (2)
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
Level 1 | Level 1 | 0
Level 2 | Level 2 | 4000

# IfcBuildingElementProxy: Rietpanel_Paneel_New_Look:Rietpanel_RP90, Rietpanel_Paneel_New_Look:Rietpanel_RP90:245357
In: Level 1
Type - Material: Binnenplaat
Type - Pset_ManufacturerTypeInformation - Manufacturer: Rietpanel
Classification: 27.1 (Uniformat); Material: Binnenplaat, PIR Isolatie, New Look Rietafwerking, Buitenplaat
Pset_BuildingElementProxyCommon - Reference: Rietpanel_RP90; sets with these values: 2
